## firmware/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_CSI_ENABLED=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=10000
CONFIG_ESP_CONSOLE_UART_BAUDRATE=921600
CONFIG_LWIP_PPP_SUPPORT=n
```
